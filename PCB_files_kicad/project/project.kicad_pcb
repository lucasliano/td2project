# Repository lucasliano/td2project

File README.md:

<!-- Badged -->

> :warning: **Work In Progress** :warning:

<!-- PROJECT LOGO -->
<br />
<p align="center">

  <h3 align="center">Security Alarm System</h3>
  
  <p align="center">
    This security system project is the final assignment of the digital technics II subjects at Universidad Tecnológica Nacional.
    <br />
    <a href="https://github.com/lucasliano/td2project"><strong>Explore the docs »</strong></a>
    <br />
    <br />
    <a href="https://github.com/lucasliano/td2project">View Demo</a>
    ·
    <a href="https://github.com/lucasliano/td2project/issues">Report Bug</a>
    ·
    <a href="https://github.com/lucasliano/td2project/issues">Request Feature</a>
  </p>
</p>

<!-- TABLE OF CONTENTS -->
<details open="open">
  <summary><h2 style="display: inline-block">Table of Contents</h2></summary>
  <ol>
    <li>
      <a href="#about-the-project">About The Project</a>
      <ol>
      <li><a href="#system-diagram">System Diagram</a></li>
      <li><a href="#main-board-pcb-and-schematics">Main Board PCB and Schematics</a></li>
      <li><a href="#equipment">Equipment</a></li>
    </ol>
    </li>
    <li><a href="#authors">Authors</a></li>
    <li><a href="#license">License</a></li>
    <li><a href="#contact">Contact</a></li>
  </ol>
</details>

## About The Project

The main idea of this project is to build a systems which allows you to detect motion in different zones within your home.  

The activation/deactivation of the system is meant to be controlled using an android app or directly trough the front keyboard. At the same time, it would be possible to configure the system to deactivate the alarm in presence of a known RFID card.

Should an error occurred, a notification will be sent to the mobile device and it will be logged into the internal EEPROM memory. The system also takes into account possible disconnections from the power supply. 

#### System Diagram
<p align="center">
  
</p>

#### Memory Map
This section describes the EEPROM memory organization. Each section provides critical information to the system. All the registers stored in the _Logs Block_ will be available through the android app.

<p align="center">
  
</p>

### Main Board PCB and Schematics

#### Schematics
The main board includes a battery charger and power supply source administrator. You will find this schematic in a PDF file in the ``` PCB_files_kicad ``` folder.

<p align="center">
  
</p>

#### PCB
<p align="center">
  
</p>

## Requirements

```
sudo apt-get install python-dev libbluetooth-dev
```

<!-- Authors -->
## Authors
* Liaño, Lucas
* Dieguez, Manuel
* Golob, Lautaro Francisco
* Crisafio, Gabriel

<!-- LICENSE -->
## License

Distributed under the GPL-3.0 License. See `LICENSE` for more information.

<!-- CONTACT -->
## Contact

Lucas Liaño - lliano@frba.utn.edu.ar

Repo Link: [https://github.com/lucasliano/td2project](https://github.com/lucasliano/td2project)

## KiCad design PCB_files_kicad/project/project.kicad_pcb

Parts:
BZ1: Buzzer; Batt
D1: LED_Green@2V; LED_D5.0mm
D2: LED_Red@2V; LED_D5.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J1, J4: Conn_01x08_Female; PinHeader_1x08_P2.54mm_Vertical
J2: S1; PinHeader_1x03_P2.54mm_Vertical
J3: S2; PinHeader_1x03_P2.54mm_Vertical
J5: Display; PinHeader_1x04_P2.54mm_Vertical
J6: HC06; PinHeader_1x04_P2.54mm_Vertical
R1, R6: 150; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R2, R3, R5, R7: 2k2; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R4, R8: 3k3; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
TP1: +3.3V; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: M24C02; DIP-8_W7.62mm

Connections:
/Buzzer: BZ1.1 (-); also elsewhere on the board
/I2C1_SCL: J5.4, R5.2, U1.6 (SCL); also elsewhere on the board
/I2C1_SDA: J5.3, R2.2, U1.5 (SDA); also elsewhere on the board
/MEASURE: R3.1; also elsewhere on the board
/UART1_RX: J6.2; also elsewhere on the board
/UART1_TX: J6.1; also elsewhere on the board
/blupill/ADC12_IN0: R3.2, R4.1; also elsewhere on the board
/blupill/ADC12_IN1: R7.2, R8.1; also elsewhere on the board
/blupill/C1_GPIO: J1.4; also elsewhere on the board
/blupill/C2_GPIO: J1.3; also elsewhere on the board
/blupill/C3_GPIO: J1.2; also elsewhere on the board
/blupill/C4_GPIO: J1.1; also elsewhere on the board
/blupill/L1_GPIO: J1.8; also elsewhere on the board
/blupill/L2_GPIO: J1.7; also elsewhere on the board
/blupill/L3_GPIO: J1.6; also elsewhere on the board
/blupill/L4_GPIO: J1.5; also elsewhere on the board
/blupill/LED1_GPIO: D1.1 (K); also elsewhere on the board
/blupill/LED2_GPIO: D2.1 (K); also elsewhere on the board
/blupill/SENSOR1_GPIO: J2.2; also elsewhere on the board
/blupill/SENSOR2_GPIO: J3.2; also elsewhere on the board
/blupill/SPI2_MISO: J4.4; also elsewhere on the board
/blupill/SPI2_MOSI: J4.3; also elsewhere on the board
/blupill/SPI2_NSS: J4.1; also elsewhere on the board
/blupill/SPI2_SCK: J4.2; also elsewhere on the board
Earth: BZ1.2 (+), H1.1, H2.1, H3.1, H4.1, J2.3, J3.3, J4.6, J5.1, J6.3, R4.2, R8.2, U1.1 (E0), U1.2 (E1), U1.3 (E2), U1.4 (VSS), U1.7 (~WC); also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R6.2

Notes on the sheet:
POWER
Mounting Holes to GND
KEYBOARD
IR SENSOR
I2C DISPLAY
RFID
SDA
SCK
MOSI
MISO
IRQ
GND
RST
3.3V
BUZZER
MAIN BOARD
BLUETOOTH
Nota: Estan al reves TX y RX, porque en el HC06 la indicación es que el RX es el de entrada, es decir que se conecta con nuestro TX.
EEPROM
Nota: WC -> GND = Write Enable

Parts:
BT1: Batt
C1, C3: 10uF; CP_Radial_D5.0mm_P2.50mm
C2: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5: 22uF; CP_Radial_D5.0mm_P2.50mm
D3, D4: 1N5822 - 500mV; D_DO-201AD_P15.24mm_Horizontal
D5: LED_Green@2V; LED_D5.0mm
J7: Barrel_Jack; BarrelJack_Horizontal
J8: USB_B_Micro; USB_Micro-B_Amphenol_10104110_Horizontal
JP1, JP2: Jumper; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1: 22uH; L_Radial_D6.0mm_P4.00mm
Q1: IRF9Z20; TO-220-3_Vertical; Mouser Number ver en electrocomponentes!
R9, R12: 2k2; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R10: 10k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R11: 15k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R13: 150; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
TP2: Vin; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: Batt; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4: Qdrain; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP5: +5V; TestPoint_THTPad_D2.0mm_Drill1.0mm
U2: TP4056; SC-70-8_Handsoldering
U3: LM1117-3.3; SOT-223-3_TabPin2
U4: MT3608; SOT-23-6_Handsoldering

Connections:
/MEASURE: C1.1, D3.2 (A), JP1.2, JP2.2, Q1.1 (G), R10.1, TP2.1, U2.4 (VCC), U2.8 (CE); also elsewhere on the board
Earth: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, D5.1 (K), J7.2, J7.3, J8.4 (ID), J8.5 (GND), J8.6 (Shield), R9.1, R10.2, R12.2, U2.1 (TEMP), U2.3 (GND), U3.1, U4.2 (GND); also elsewhere on the board
unnamed: D4.2 (A), L1.2, U4.1 (SW)
unnamed: D5.2 (A), R13.2
unnamed: J7.1, JP1.1
unnamed: J8.1 (VBUS), JP2.1
unnamed: R9.2, U2.2 (PROG)
unnamed: R11.2, R12.1, U4.3 (FB)

Notes on the sheet:
Wall Input Voltage
Battery Cell
Battery Voltage Booster 4.2V -> 5V
Protection Diode
Gate PMOSFET
PullDown Resistor
Battery Charge Module @ 545mA
Power Indicator Led
|VGS(ON)| > |-3.7v|
Circuit reference: https://www.youtube.com/watch?v=GRd9uTwg7r4
Voltage Regulator 3.3V

Parts:
U5: BluePill_Connector; bluepill

Connections:
/Buzzer: U5.27 (PB1); also elsewhere on the board
/I2C1_SCL: U5.10 (PB8); also elsewhere on the board
/I2C1_SDA: U5.8 (PB9); also elsewhere on the board
/UART1_RX: U5.12 (PB7); also elsewhere on the board
/UART1_TX: U5.14 (PB6); also elsewhere on the board
/blupill/ADC12_IN0: U5.9 (PA0); also elsewhere on the board
/blupill/ADC12_IN1: U5.11 (PA1); also elsewhere on the board
/blupill/C1_GPIO: U5.16 (PB5); also elsewhere on the board
/blupill/C2_GPIO: U5.18 (PB4); also elsewhere on the board
/blupill/C3_GPIO: U5.20 (PB3); also elsewhere on the board
/blupill/C4_GPIO: U5.28 (PA10); also elsewhere on the board
/blupill/L1_GPIO: U5.13 (PA2); also elsewhere on the board
/blupill/L2_GPIO: U5.15 (PA3); also elsewhere on the board
/blupill/L3_GPIO: U5.19 (PA5); also elsewhere on the board
/blupill/L4_GPIO: U5.21 (PA6); also elsewhere on the board
/blupill/LED1_GPIO: U5.23 (PA7); also elsewhere on the board
/blupill/LED2_GPIO: U5.29 (PB10); also elsewhere on the board
/blupill/SENSOR1_GPIO: U5.30 (PA9); also elsewhere on the board
/blupill/SENSOR2_GPIO: U5.32 (PA8); also elsewhere on the board
/blupill/SPI2_MISO: U5.36 (PB14); also elsewhere on the board
/blupill/SPI2_MOSI: U5.34 (PB15); also elsewhere on the board
/blupill/SPI2_NSS: U5.40 (PB12); also elsewhere on the board
/blupill/SPI2_SCK: U5.38 (PB13); also elsewhere on the board
Earth: U5.4 (GND), U5.37 (GND), U5.39 (GND); also elsewhere on the board

Notes on the sheet:
Bluepill connector
Power
TIM2_CH1_ETR

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
Board: 2 copper layers, 65.0 x 100.0 mm, 53 parts (0 on the bottom side), 37 nets.

Other parts of the board:
C6: 22uF; CP_Radial_D5.0mm_P2.50mm
LogoUTN.BA-Letras: UTN.BA-Letras

Their connections:
Earth: C6.2; also elsewhere on the board

## Code that names these connections

File software/software.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.GPIOParameters=GPIO_PuPd
PA10.GPIO_PuPd=GPIO_PULLDOWN
PA10.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Signal=GPIO_Output
PA3.Signal=GPIO_Output
PA5.Signal=GPIO_Output
PA6.Signal=GPIO_Output
PA7.GPIOParameters=PinState
PA7.PinState=GPIO_PIN_SET
PA7.Signal=GPIO_Output
PA8.Signal=GPIO_Input
PA9.Signal=GPIO_Input
PB1.Signal=GPIO_Output
PB10.GPIOParameters=PinState
PB10.PinState=GPIO_PIN_SET
PB10.Signal=GPIO_Output
PB12.GPIOParameters=PinState
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB3.GPIOParameters=GPIO_PuPd
PB3.GPIO_PuPd=GPIO_PULLDOWN
PB3.Signal=GPIO_Input
PB4.GPIOParameters=GPIO_PuPd
PB4.GPIO_PuPd=GPIO_PULLDOWN
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_PuPd
PB5.GPIO_PuPd=GPIO_PULLDOWN
PB5.Signal=GPIO_Input
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC13-TAMPER-RTC.GPIOParameters=PinState
PC13-TAMPER-RTC.PinState=GPIO_PIN_SET
PC13-TAMPER-RTC.Signal=GPIO_Output
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_Timout=400
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2021-08-25 First push :D
2021-08-25 Update README -> Adding Schematic link
2021-08-25 Primer push bt
2021-08-25 Adding components to the README
2021-09-02 Improving repo settings
2021-09-02 More gitignore improvments
2021-09-02 Adding STM project
2021-09-02 UART 7 data bits to 8 data bits
2021-09-02 Create LICENSE
2021-09-03 PCB - Placing components
2021-09-03 PCB - Starting to route
2021-09-05 PCB v1.0 done
2021-09-16 SCH version 1.3
2021-09-20 Lot of changes.. BOM was added and UTN logo too
2021-09-23 Sche rev 1.4 - PCB rev 1.2
2021-09-27 Schematic v1.5 - PCB v1.3
2021-09-27 Schematic v1.6
2021-09-29 Schematic v1.7 - PCB v1.4
2021-09-30 PCB v1.5
2021-09-30 Minor changes
2021-09-30 Version de fabricación!
2021-10-03 PCB folder renamed
2021-10-03 Adjusting Tasks and FreeRTOS configs
2021-10-03 Error Handler in while(1)
2021-10-03 PCB mini bug fix
2021-10-04 Schematic pdf updated
2021-10-06 PCB images were added
2021-10-07 Intentando agregar RFID. Cambie configuraciones de CLK y de FreeRTOS (RAM que toma el SO)
2021-10-07 Adding .launch to gitignore
2021-10-07 Fixing gitignore
2021-10-07 Update README.md
    Minor change on image
2021-10-14 RFID working
2021-10-14 teclado etc
2021-10-14 Codigo manu integrado completamente
2021-10-15 RFID toggling state working
2021-10-16 Adding new eeprom datasheet
2021-10-16 EEPROM primer acercamiento. Sin testear!
2021-10-26 Working on eeprom. Not working yet
2021-10-26 Adding gpio functionalities
2021-10-26 minor change on readme
2021-10-26 i2c freq = 100kHz
2021-10-26 LCD drivers
2021-10-26 ADC kinda working
2021-11-04 working with project configuration (adding ADC w/ DMA)
2021-11-04 EEPROM working as expected
2021-11-04 Adding ADC w/ DMA logic. Not working!
2021-11-07 Working out keyboard
2021-11-07 Fixing initial LEDs GPIO state
2021-11-07 Saving card's ID
2021-11-08 Adding EEPROM primitives
2021-11-08 Now we only accept valid ID cards
2021-11-08 Tarea para agregar tarjetas validas
2021-11-08 agregamos diagrama del mapa de memoria
2021-11-10 trying DMA w/ semaphore. Not working yet
2021-11-12 EEPROM routines were modify + ADC new idea
2021-11-13 Adding bluetooth interface
2021-11-13 removing bt client
2021-11-14 working on readme
2021-11-14 Adding background to diagram
2021-11-27 ADC now working. STM project name was changed
2021-12-04 Improving IR sensors behaviour
2021-12-05 Removing debug configs
2021-12-05 LCD working fine
2021-12-08 UART working
2021-12-10 UART improvements
2021-12-10 More photosss
2021-12-11 Working fine
2021-12-12 almost done
2021-12-13 Adding mini CLI
2021-12-13 update time
2021-12-14 set_time
2021-12-14 unused function was removed from .h
2021-12-14 adding images
2021-12-14 add readme to CLI
2021-12-14 adding more images
2021-12-14 working w/ datasheets
